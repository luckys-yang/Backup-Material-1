# Keil uVision project STM32F103.uvprojx, settings and files
target STM32F103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\User;..\System;..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\FWlib\inc;..\Libraries\FWlib\src;..\bsp\w25qxx;..\bsp\CAN;..\bsp\key;..\bsp\LCD_2.8_ILI9341;..\bsp\LED;..\bsp\USART;..\bsp\XPT2046;..\bsp\ESP8266;..\bsp\RS485;..\bsp\OLED;..\bsp\LCD_1.8_ST7735;..\bsp\w25qxx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h
  group BSP
    ../bsp/LED/: bsp_led.c
    ../bsp/USART/: bsp_usart.c
    ../bsp/LCD_1.8_ST7735/: bsp_lcd_st7735.c
    ../bsp/w25qxx/: bsp_w25qxx.c
  group SYSTEM
    ../System/: system_f103.c
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
